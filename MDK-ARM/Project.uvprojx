# Keil uVision project Project.uvprojx, settings and files
target CottonPacketSenor (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CottonSenor +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  --output ./bin/CottonSenor.bin ./Obj/CottonSenor.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Platform\midlayer\include;..\USER\include;..\USER\src;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Platform\driver\include;..\USER\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../USER/: main.c
    ../USER/src/: apll.c dataBase.c allBleMesh.c allGprs.c cJSON.c endian_swap.c cJSON_Utils.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c stm32f10x_it.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../: readme.txt
  group Driver
    ../Platform/driver/src/: driverGpio.c driverIWDog.c driverNetwork.c DriverPressure.c driverTemper.c driverFlash.c driverUart.c driverDebug.c driverGprs.c driverBleMesh.c
  group Midlayer
    ../Platform/midlayer/src/: driverFile.c driverManager.c driverRtc.c driverTime.c driverTimer.c queue.c sheet.c timer.c
software components: CMSIS:CORE 5.0.1
